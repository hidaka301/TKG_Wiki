# Repository hidaka301/TKG_Wiki (continued)

## KiCad design 02_詳細検討/20_パワー電源制御基板/ECcircuit.kicad_pcb (continued)

Parts:
C3: 0.1uF(1608); C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3: SBM1045VSS; D_DO-201_P15.24mm_Horizontal
D7, D8: U1ZB15; D_SMB_Handsoldering
J3, J4, J5: Output; AMASS_XT60-F_1x02_P7.20mm_Vertical
J6, J8: Output; AMASS_XT30U-F_1x02_P5.0mm_Vertical
Q2, Q3: 2SJ555; TO-3P-3_Vertical
R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: TBD; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 51; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+BATT: C3.1, D3.1 (K), D7.1 (K), D8.1 (K), Q2.3 (S), Q3.3 (S), R6.1; also elsewhere on the board
GNDPWR: J3.1, J4.1, J5.1, J6.1, J8.1; also elsewhere on the board
unnamed: C3.2, R6.2, R7.1, R8.1, R9.1
unnamed: D3.2 (A), J3.2, J4.2, J5.2, J6.2, J8.2, Q2.2 (D), Q3.2 (D)
unnamed: D7.2 (A), Q2.1 (G), R8.2
unnamed: D8.2 (A), Q3.1 (G), R9.2
PW_Control: R7.2; also elsewhere on the board

Notes on the sheet:
突入電流防止用コンデンサ(ソフト充電) https://www.rohm.co.jp/electronics-basics/transistors/tr_what8 https://detail-infomation.com/load-switch/
Vgsの絶対最大定格が±20Vなので12V~14Vとなるような抵抗を選定すること LiPo(6cell) 13kΩ( 4.2V*6=25.2V で14.2Vとなる) →実測結果は24V時13.49V
せん頭電流-240Aのため、1個で問題ない (異常に対する対処はヒューズ)

Board: 2 copper layers, 70.0 x 55.0 mm, 49 parts (0 on the bottom side), 23 nets.

## KiCad design 02_詳細検討/21_電流検出基板/CurrentSensorBoard_HXS-50-NP.kicad_pcb

Board: 2 copper layers, 74.0 x 74.0 mm, 80 parts (8 on the bottom side), 29 nets.

Parts:
C1: 220uF(P-01302); C_Elec_10x10.2
C2, C3, C7, C10: 22uF(P-08294); CP_Radial_D6.3mm_P2.50mm
C4, C6, C12, C13, C14, C15, C16, C17: 47nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C24: 0.1uF(NJM2746); C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C8, C18, C19, C20: 4.7nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C25, C26: 0.1uF(NJM8502); C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C11, C21, C22, C23: 0.022uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: BLUE; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2, D3, D4, D5, D6, D7, D8, D9: SS2040FL(I-02073); D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1, J2, J3, J4: XT30; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J5: JST XH; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J6, J7, J8, J9: XT30; AMASS_XT30U-F_1x02_P5.0mm_Vertical
L1: 4.7uH(P-14978); L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R1: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 51k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R6, R7, R10: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R11, R12, R13: 27k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15, R16, R17: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 10k(P-03277); Potentiometer_Vishay_T73YP_Vertical
TP1, TP3, TP4, TP5: Curr; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
TP2: Gnd; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U1, U4, U5, U6: HXS_50-NP; HXS_50-NP-NoPad
U2: NJM2746; SO-8_5.3x6.2mm_P1.27mm
U3: MAU108; Converter_DCDC_Murata_NMAxxxxSC_THT
U7, U8: NJM8502; VSSOP-8_3.0x3.0mm_P0.65mm

Connections:
+5V: C1.2, C2.1, C4.2, C5.2, C12.2, C13.2, C14.2, D1.2 (A), D2.1 (K), D4.1 (K), D6.1 (K), D8.1 (K), J5.2, L1.1, R1.2, U1.9 (Vcc), U2.8 (V+), U4.9 (Vcc), U5.9 (Vcc), U6.9 (Vcc)
+12V: C7.1, C9.2, C24.2, R3.2, U3.6 (VOUT+), U7.8 (V+), U8.8 (V+)
-12V: C10.2, C25.2, C26.2, R4.1, U3.4 (VOUT-), U7.4 (V-), U8.4 (V-)
Cur1: D6.2 (A), D7.1 (K), J5.3, R16.1, TP1.1
Cur2: D8.2 (A), D9.1 (K), J5.4, R17.1, TP5.1
Cur3: D2.2 (A), D3.1 (K), J5.5, R14.1, TP3.1
Cur4: D4.2 (A), D5.1 (K), J5.6, R15.1, TP4.1
GND: C1.1, C2.2, C3.2, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C24.1, C25.1, C26.1, D3.2 (A), D5.2 (A), D7.2 (A), D9.2 (A), J5.1, R2.1, R3.1, R4.2, R9.1, TP2.1, U1.10 (Gnd), U2.4 (V-), U2.5 (+), U2.6 (-), U3.2 (VIN-), U3.5 (0V), U4.10 (Gnd), U5.10 (Gnd), U6.10 (Gnd)
unnamed: C3.1, L1.2, U3.1 (VIN+)
unnamed: C8.2, R6.1, U1.11 (Out)
unnamed: C11.1, R6.2, R8.1, U8.2 (-)
unnamed: C11.2, R8.2, R16.2, U8.1
unnamed: C18.2, R5.1, U4.11 (Out)
unnamed: C19.2, R7.1, U5.11 (Out)
unnamed: C20.2, R10.1, U6.11 (Out)
unnamed: C21.1, R5.2, R11.1, U7.2 (-)
unnamed: C21.2, R11.2, R14.2, U7.1
unnamed: C22.1, R7.2, R12.1, U7.6 (-)
unnamed: C22.2, R12.2, R15.2, U7.7
unnamed: C23.1, R10.2, R13.1, U8.6 (-)
unnamed: C23.2, R13.2, R17.2, U8.7
unnamed: D1.1 (K), R9.2
unnamed: J1.1, J6.1
unnamed: J2.1, J7.1
unnamed: J3.1, J8.1
unnamed: J4.1, J9.1
unnamed: R1.1, RV1.2
unnamed: R2.2, RV1.1, U2.3 (+)
ref1.65V: C6.2, C15.2, C16.2, C17.2, U1.12 (Ref), U2.1, U2.2 (-), U4.12 (Ref), U5.12 (Ref), U6.12 (Ref), U7.3 (+), U7.5 (+), U8.3 (+), U8.5 (+)

## Commit log

2023-04-09 update 設計資料追加
2024-03-31 add 2023の基板CADデータを追加
2024-05-12 2024
    2024年度フォルダを作成
2024-05-12 2024フォルダ作成
    2024フォルダ作成
