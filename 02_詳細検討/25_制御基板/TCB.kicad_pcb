# Repository hidaka301/TKG_Wiki

## KiCad design 02_詳細検討/25_制御基板/TCB.kicad_pcb

Parts:
BATCur1: JST_XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
C2, C3, C4, C10: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
CAN1: JST_XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
CLK_C1: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
CurrDet1: JST_XH; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
D1, D5, D6, D7, D9, D11, D12, D13, D14, D15: BZT52C3V6; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
D2: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: YELLOW; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
E1J1: E1; IDC-Header_2x07_P2.54mm_Vertical
EXT_LED1: JST_XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_ISO14580_Pad
J1: XBee; PinSocket_1x05_P2.54mm_Vertical
JP1: 3V3; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
LED_R1, LED_R2, LED_R3, LED_R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
M1C1, M1C2, M5C1, M6C1, M12C1, M12C2, M35C2, M60C1, M60C2, M94C1, M94C2, M97C1, M97C2: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
M35C1: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
M94C3, M97C3: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
MG_IO1: JST_XH; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
PWM_chA_J1: JST_XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
PWM_chB_J1: JST_XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
PWM_chC_J1: JST_XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
PWM_chD_J1: JST_XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R4, R7, R8, R10, R11: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2, RN3, RN4: 4.7k; R_Array_Concave_4x0402
ResC1: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
Res_R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TaimatsuIO1: JST_XH; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
U1: RX631_100pin; LQFP-100_14x14mm_P0.5mm
U2: SSD1306(128x64Display)
U4: SN65HVD230(SOIC); SOIC-8_3.9x4.9mm_P1.27mm
U7: MPU9250_Ali_module; PinSocket_1x10_P2.54mm_Vertical
X1: SG-210STF; Oscillator_SMD_SeikoEpson_SG210-4Pin_2.5x2.0mm

Connections:
+3V3: C14.1, CLK_C1.1, D9.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), E1J1.8, JP1.2 (B), M1C1.1, M1C2.1, M6C1.1, M12C1.2, M12C2.2, M35C1.1, M35C2.1, M60C1.2, M60C2.2, M94C1.1, M94C2.1, M94C3.1, M97C1.2, M97C2.2, M97C3.2, MG_IO1.2, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN1.4 (R4.1), RN2.8 (R1.2), Res_R1.2, U1.1 (VREFH), U1.6 (VBATT), U1.14 (VCC), U1.35 (VCC_USB), U1.60 (VCC), U1.96 (VREFH0), U1.97 (AVCC0), U2.2 (VCC), U4.3 (VCC), U7.1 (Vcc), X1.4 (Vcc); also elsewhere on the board
+5V: CurrDet1.2, EXT_LED1.1, TaimatsuIO1.2; also elsewhere on the board
/ADC1: C2.1, D1.1 (K), D14.2 (A), R7.1, U1.93 (P41/AN1/IRQ9)
/ADC2: C3.1, D5.1 (K), D12.2 (A), R8.1, U1.92 (P42/AN2/IRQ10)
/ADC3: C4.1, D6.1 (K), D15.2 (A), R10.1, U1.91 (P43/AN3/IRQ11)
/ADC4: C10.1, D7.1 (K), D13.2 (A), R11.1, U1.90 (P44/AN4/IRQ12)
/ADC5: U1.89 (P45/AN5/IRQ13-B); also elsewhere on the board
/ADC6: BATCur1.2, D9.2 (A), D11.1 (K), U1.88 (P46/AN6/IRQ14)
/DistanceDetect: CurrDet1.6, MG_IO1.6, R11.2
/EMLE: E1J1.4, RN2.3 (R3.1), U1.2 (EMLE)
/ESTOP: U1.15 (P35/NMI); also elsewhere on the board
/EXT_LED: LED_R5.1, U1.57 (PB3)
/Enc_chE_A: U1.24; also elsewhere on the board
/Enc_chE_B: U1.23 (P25/RXD3); also elsewhere on the board
/Enc_chF_A: U1.26 (P22); also elsewhere on the board
/Enc_chF_B: U1.25 (P23/TXD3); also elsewhere on the board
/Enc_chG_A: U1.32 (P14/USB0_DPUPE); also elsewhere on the board
/Enc_chG_B: U1.49 (PC3); also elsewhere on the board
/Enc_chH_A: U1.52 (PC0); also elsewhere on the board
/Enc_chH_B: U1.51 (PC1); also elsewhere on the board
/IIC2_SCL: U1.30 (P16/USB0_VBUS), U2.3 (SCL)
/IIC2_SDA: U1.29 (P17/TXD3), U2.4 (SDA)
/LED_GREEN: LED_R3.1, U1.56 (PB4)
/LED_RED: LED_R1.1, U1.54 (PB6)
/LED_YELLOW: LED_R2.1, U1.55 (PB5/TXD0)
/LoadingN: MG_IO1.4, U1.85 (PD1)
/LoadingP: MG_IO1.5, U1.84 (PD2)
/MD: E1J1.7, RN1.6 (R3.2), U1.7 (MD/FINED)
/MISOB: U1.75 (PE3); also elsewhere on the board
/MOSIA: U1.46 (PC6), U7.4 (MOSI)
/MOSIB: U1.72 (PE6); also elsewhere on the board
/OPRON: U1.33 (P13/TXD2-A); also elsewhere on the board
/OPRON_LED: U1.34 (P12/RXD2-A); also elsewhere on the board
/PWM_chA: PWM_chA_J1.2, RN3.1 (R1.1), U1.70 (PA0)
/PWM_chB: PWM_chB_J1.2, RN3.3 (R3.1), U1.66 (PA4)
/PWM_chC: PWM_chC_J1.2, RN4.1 (R1.1), TaimatsuIO1.3, U1.64 (PA6)
/PWM_chD: PWM_chD_J1.2, RN4.3 (R3.1), TaimatsuIO1.5, U1.61 (PB0)
/PWON: U1.31 (P15/RXD1); also elsewhere on the board
/RES#: E1J1.13, ResC1.1, Res_R1.1, U1.10 (RES#)
/RSPCKA: U1.47 (PC5), U7.3 (RSPCK)
/RSPCKB: U1.73 (PE5); also elsewhere on the board
/Rx1: U1.27 (P21/RXD0); also elsewhere on the board
/Rx2: U1.50 (PC2); also elsewhere on the board
/Rx3: J1.4, U1.17 (P33/IRQ3)
/SSLA0: U1.48 (PC4), U7.9 (CS)
/SSLB0: U1.74 (PE4); also elsewhere on the board
/SSLB1: U1.78 (PE0)
/SSLB2: U1.77 (PE1)
/SSLB3: U1.76 (PE2)
/ShutterCL: MG_IO1.3, U1.86 (PD0)
/TCK: E1J1.1, RN1.8 (R1.2), U1.21 (P27/TCK)
/TD0: E1J1.5, RN1.7 (R2.2), U1.22 (P26/TDO/TXD1)
/TDI: E1J1.11, RN2.1 (R1.1), U1.20 (P30/TDI/RXD1)
/TMS: E1J1.9, RN1.5 (R4.2), U1.19 (P31/TMS)
/TRST#: E1J1.3, RN2.4 (R4.1), U1.16 (P34/TRST#)
/TaimatsuNC1: TaimatsuIO1.6, U1.83 (PD3)
/TaimatsuNC2: TaimatsuIO1.7, U1.82 (PD4)
/Tx1: U1.28 (P20/TXD0); also elsewhere on the board
/Tx3: J1.5, U1.18 (P32/IRQ2)
/XTAL: U1.13 (P36/XTAL), X1.3 (OUT)
//PWM_chA: PWM_chA_J1.3, RN3.2 (R2.1), U1.69 (PA1)
//PWM_chB: PWM_chB_J1.3, RN3.4 (R4.1), U1.65 (PA5)
//PWM_chC: PWM_chC_J1.3, RN4.2 (R2.1), TaimatsuIO1.4, U1.63 (PA7)
//PWM_chD: PWM_chD_J1.3, RN4.4 (R4.1), U1.59 (PB1/RXD0)
CAN_RX: U1.39 (P55), U4.4 (R)
CAN_TX: U1.40 (P54), U4.1 (D)
GND: BATCur1.1, C2.2, C3.2, C4.2, C10.2, C14.2, CLK_C1.2, CurrDet1.1, D1.2 (A), D2.1 (K), D3.1 (K), D4.1 (K), D5.2 (A), D6.2 (A), D7.2 (A), D11.2 (A), E1J1.2, E1J1.12, E1J1.14, H1.1, H2.1, H3.1, H4.1, J1.1, M1C1.2, M1C2.2, M5C1.2, M6C1.2, M12C1.1, M12C2.1, M35C1.2, M35C2.2, M60C1.1, M60C2.1, M94C1.2, M94C2.2, M94C3.2, M97C1.1, M97C2.1, M97C3.1, MG_IO1.1, PWM_chA_J1.1, PWM_chB_J1.1, PWM_chC_J1.1, PWM_chD_J1.1, R4.1, RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN3.5 (R4.2), RN3.6 (R3.2), RN3.7 (R2.2), RN3.8 (R1.2), RN4.5 (R4.2), RN4.6 (R3.2), RN4.7 (R2.2), RN4.8 (R1.2), ResC1.2, TaimatsuIO1.1, U1.3 (VREFL), U1.12 (VSS), U1.38 (VSS_USB), U1.62 (VSS), U1.94 (VREFL0), U1.99 (AVSS0), U2.1 (GND), U4.2 (GND), U7.2 (GND), X1.2 (GND); also elsewhere on the board
unnamed: CAN1.1, R6.1, U4.6 (CANL)
unnamed: CAN1.2, R6.2, U4.7 (CANH)
unnamed: CurrDet1.3, R7.2
unnamed: CurrDet1.4, R8.2
unnamed: CurrDet1.5, R10.2
unnamed: D2.2 (A), LED_R1.2
unnamed: D3.2 (A), LED_R2.2
unnamed: D4.2 (A), LED_R3.2
unnamed: EXT_LED1.2, LED_R5.2
unnamed: J1.3, JP1.1 (A)
unnamed: M5C1.1, U1.5 (VCL)
unnamed: R4.2, U4.8 (Rs)
UB: E1J1.10, RN2.2 (R2.1), U1.45 (PC7), U7.7 (MISO)

Notes on the sheet:
[インターフェース] たいまつアーム付加基板
IMU (MOSIAはUB端子経由でプルアップされていることに注意)
CRX1
SS2040FLです パッドサイズ間違い
[インターフェース] 電流検出基板
(注)センサ用IO(PD0~4)は、 入力プルアップ抵抗を有効とすること
CTX1
LCD
状態表示灯
プルアップ抵抗つけておくべきだったかも
取付穴
[インターフェース] MGセンサIO基板
バッテリ電流を外付けで 検出できるようにしておく (通常使用しない、開発用機能)
シリアル通信(3V3) Debug用XBee接続

Parts:
ADM_C1: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C6, C7, C8, C9: 0.1u 10V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C11, C12, C13: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D8: SS2040FL(I-02073); D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
ESTOP1: JST_XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
JP2, JP3: RS232C; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
OPRON1: JST_XH; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
PWON1: JST_XH; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R12, R14, R30: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R15, R32: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RS232C_J1, RS232C_J2: JST_XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
TKGCOM_J1, TKGCOM_J2: JST_XH; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
U10: ADM3202ARUZ; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3V3: ADM_C1.1, D8.1 (K), R12.2, R30.2, U10.16 (VCC); also elsewhere on the board
+5V: OPRON1.2, PWON1.2, TKGCOM_J1.2, TKGCOM_J2.2; also elsewhere on the board
/ADC5: C13.1, R15.1; also elsewhere on the board
/DataTransfer/CoREjpEXT_In: JP3.1 (A), TKGCOM_J1.3, TKGCOM_J2.3, U10.8 (R2IN)
/ESTOP: C11.1, R32.1; also elsewhere on the board
/OPRON: C12.1, R13.1; also elsewhere on the board
/OPRON_LED: OPRON1.4; also elsewhere on the board
/PWON: PWON1.3; also elsewhere on the board
/Rx1: U10.12 (R1OUT); also elsewhere on the board
/Rx2: JP2.2 (B), JP3.2 (B); also elsewhere on the board
/Tx1: U10.11 (T1IN); also elsewhere on the board
GND: ADM_C1.2, C8.2, C9.2, C11.2, C12.2, C13.2, ESTOP1.1, OPRON1.1, PWON1.1, R14.1, RS232C_J1.1, RS232C_J2.1, TKGCOM_J1.1, TKGCOM_J2.1, U10.10 (T2IN), U10.15 (GND); also elsewhere on the board
unnamed: C6.1, U10.1 (C1+)
unnamed: C6.2, U10.3 (C1-)
unnamed: C7.1, U10.4 (C2+)
unnamed: C7.2, U10.5 (C2-)
unnamed: C8.1, U10.6 (VS-)
unnamed: C9.1, U10.2 (VS+)
unnamed: D8.2 (A), PWON1.4, R14.2, R15.2
unnamed: ESTOP1.2, R30.1, R32.2
unnamed: OPRON1.3, R12.1, R13.2
unnamed: RS232C_J1.2, RS232C_J2.2, U10.13 (R1IN)
unnamed: RS232C_J1.3, RS232C_J2.3, U10.14 (T1OUT)
unnamed: JP2.1 (A), U10.9 (R2OUT)

Notes on the sheet:
リセット端子が必要になった際に拡張できるように1ピン増やした
(ToDo)ﾌﾟﾙﾀﾞｳﾝ抵抗を外すか、入力インピーダンス計算すること
受信機信号入力(CoREjp)
E-STOP

Parts:
5V_J1, 5V_J2: JST XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
C1: 100u; CP_Radial_D8.0mm_P5.00mm
D10: BLUE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED_R4: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RegC1: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
RegC2: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U3: AZ1086H-3.3; SOT-223-3_TabPin2

Connections:
+3V3: RegC2.1, U3.2 (Vout); also elsewhere on the board
+5V: 5V_J1.2, 5V_J2.2, C1.1, LED_R4.1, RegC1.1, U3.3 (Vin); also elsewhere on the board
GND: 5V_J1.1, 5V_J2.1, C1.2, D10.1 (K), RegC1.2, RegC2.2, U3.1 (Gnd); also elsewhere on the board
unnamed: D10.2 (A), LED_R4.2

Parts:
C5: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C19: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
ENC_chE_J1: JST_XH; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
ENC_chF_J1: JST_XH; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
ENC_chG_J1: JST_XH; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
ENC_chH_J1: JST_XH; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
Enc_chA_J1: JST_XH; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
LTC_C4: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R1, R5, R9: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17: 60.1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
T4: DLW43SH101XK2
U8: LTC6820; MSOP-16_3x4mm_P0.5mm
U9, U13: AM26LV32E(TSSOP); TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3V3: C16.1, C19.1, Enc_chA_J1.2, LTC_C4.1, R1.2, U8.1 (EN), U8.6 (VCCS), U8.8 (PHA), U8.9 (VCC), U8.12 (MSTR), U9.16 (VCC), U13.16 (VCC); also elsewhere on the board
+5V: ENC_chE_J1.2, ENC_chF_J1.2, ENC_chG_J1.2, ENC_chH_J1.2; also elsewhere on the board
/Enc_chE_A: U9.3 (OUT); also elsewhere on the board
/Enc_chE_B: U9.5 (OUT); also elsewhere on the board
/Enc_chF_A: U9.11 (OUT); also elsewhere on the board
/Enc_chF_B: U9.13 (OUT); also elsewhere on the board
/Enc_chG_A: U13.3 (OUT); also elsewhere on the board
/Enc_chG_B: U13.5 (OUT); also elsewhere on the board
/Enc_chH_A: U13.11 (OUT); also elsewhere on the board
/Enc_chH_B: U13.13 (OUT); also elsewhere on the board
/MISOB: R1.1, U8.3 (MISO); also elsewhere on the board
/MOSIB: U8.2 (MOSI); also elsewhere on the board
/RSPCKB: U8.4 (SCK); also elsewhere on the board
/SSLB0: U8.5 (/CS); also elsewhere on the board
GND: C5.2, C16.2, C19.2, ENC_chE_J1.1, ENC_chF_J1.1, ENC_chG_J1.1, ENC_chH_J1.1, Enc_chA_J1.1, LTC_C4.2, R9.2, U8.7 (POL), U8.13 (SLOW), U8.14 (GND), U9.4 (ENABLE), U9.8 (GND), U9.12 (ENABLE), U13.4 (ENABLE), U13.8 (GND), U13.12 (ENABLE); also elsewhere on the board
unnamed: C5.1, R16.2, R17.1
unnamed: ENC_chE_J1.3, U9.2 (E+)
unnamed: ENC_chE_J1.4, U9.1 (E-)
unnamed: ENC_chE_J1.5, U9.6 (E+)
unnamed: ENC_chE_J1.6, U9.7 (E-)
unnamed: ENC_chF_J1.3, U9.10 (E+)
unnamed: ENC_chF_J1.4, U9.9 (E-)
unnamed: ENC_chF_J1.5, U9.14 (E+)
unnamed: ENC_chF_J1.6, U9.15 (E-)
unnamed: ENC_chG_J1.3, U13.2 (E+)
unnamed: ENC_chG_J1.4, U13.1 (E-)
unnamed: ENC_chG_J1.5, U13.6 (E+)
unnamed: ENC_chG_J1.6, U13.7 (E-)
unnamed: ENC_chH_J1.3, U13.10 (E+)
unnamed: ENC_chH_J1.4, U13.9 (E-)
unnamed: ENC_chH_J1.5, U13.14 (E+)
unnamed: ENC_chH_J1.6, U13.15 (E-)
unnamed: Enc_chA_J1.3, T4.2 (AB)
unnamed: Enc_chA_J1.4, T4.1 (AA)
unnamed: R5.1, U8.16 (IBIAS)
unnamed: R5.2, R9.1, U8.15 (ICMP)
unnamed: R16.1, T4.3 (SA), U8.11 (IP)
unnamed: R17.2, T4.4 (SB), U8.10 (IM)

Notes on the sheet:
2相型
AS5048A(SPI)
本当にSLOW端子設定はこっちでないとダメ？

Board: 2 copper layers, 100.0 x 100.0 mm, 124 parts (1 on the bottom side), 114 nets.

## KiCad design 02_詳細検討/20_パワー電源制御基板/ECcircuit.kicad_pcb

Parts:
C1: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C6: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C7: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C5: 4.7uF50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: LED Red; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: LED Blue; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: microsMD010[Aki P-01316]; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
F2: Keystone Electronics 3568-10; Fuseholder_Blade_Mini_Keystone_3568
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1, J7: ControlInput; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: Battery IN; AMASS_XT60-M_1x02_P7.20mm_Vertical
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R1: 6.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R12, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 51; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R30: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SSSS213202
SW2: ESTOP_XH(JST); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
U1: NJM2746; SO-8_5.3x6.2mm_P1.27mm
U2, U3: PC817; DIP-4_W7.62mm
U4: 74LVC2G08; SSOP-8_2.95x2.8mm_P0.65mm

Connections:
+3.3V: C1.1, C2.1, D5.2 (A), J1.2, U1.8 (V+), U3.4, U4.8 (VCC)
+BATT: C5.1, D2.2 (A), F2.2, R1.1; also elsewhere on the board
/PWON: J1.3, JP1.1 (A), R2.2, U4.1
/PWON2: J7.3, JP1.2 (B), R13.2, U4.2
/VoltageDetect: C7.1, J1.4, J7.4, R3.1
GND: C1.2, C2.2, C4.2, C7.2, J1.1, J7.1, R2.1, R5.1, R12.2, R13.1, R30.1, U1.4 (V-), U1.5 (+), U1.6 (-), U2.2, U4.4 (GND), U4.5, U4.6
GNDPWR: C5.2, J2.1, R10.1, SW1.3 (C), U2.3, U3.2; also elsewhere on the board
unnamed: C4.1, R4.2, U2.1
unnamed: C6.1, R11.1, R12.1, U1.2 (-)
unnamed: C6.2, R3.2, R11.2, U1.1
unnamed: D2.1 (K), R10.2
unnamed: D5.1 (K), R30.2
unnamed: F1.1, R1.2
unnamed: F1.2, U3.1
unnamed: F2.1, J2.2
unnamed: R4.1, U4.7
unnamed: R5.2, U1.3 (+), U3.3
unnamed: SW1.2 (B), SW2.1 (A), U2.4
PW_Control: SW2.2 (B); also elsewhere on the board

Notes on the sheet:
ヒューズの代わりに電流センサを入れれば、電流計測も可能 30A定格な点に注意
PWON信号無視用
[参考] https://memoteki.net/archives/1352#index_id4 https://robotry.hatenablog.com/entry/2020/06/05/200000 (分圧抵抗)http://sim.okawa-denshi.jp/rercal.php
https://akizukidenshi.com/catalog/g/gI-13765/
[次回改訂] 電圧の変換精度と再現性が悪い 素直に絶縁のオペアンプでも使うべき
1次側2mAとする(順方向電圧1.2Vで計算) 3.3V：ON,0V：OFF
ﾌﾟﾙﾀﾞｳﾝ
バッテリ電圧検出
[次回改訂] オープンドレイン入力にすればAND不要
